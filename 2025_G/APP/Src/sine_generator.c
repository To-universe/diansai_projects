#include "sine_generator.h"

#include <math.h>
#include <string.h>

// static uint8_t sine_table[256] = {
//     0x80, 0x83, 0x86, 0x89, 0x8c, 0x8f, 0x92, 0x95, 0x99, 0x9c, 0x9f, 0xa2, 0xa5, 0xa8, 0xab, 0xae,
//     0xb1, 0xb4, 0xb6, 0xb9, 0xbc, 0xbf, 0xc1, 0xc4, 0xc7, 0xc9, 0xcc, 0xce, 0xd1, 0xd3, 0xd6, 0xd8,
//     0xda, 0xdc, 0xdf, 0xe1, 0xe3, 0xe5, 0xe7, 0xe8, 0xea, 0xec, 0xed, 0xef, 0xf1, 0xf2, 0xf3, 0xf5,
//     0xf6, 0xf7, 0xf8, 0xf9, 0xfa, 0xfb, 0xfc, 0xfc, 0xfd, 0xfe, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff,
//     0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xfe, 0xfd, 0xfd, 0xfc, 0xfb, 0xfb, 0xfa, 0xf9, 0xf8, 0xf6,
//     0xf5, 0xf4, 0xf3, 0xf1, 0xf0, 0xee, 0xed, 0xeb, 0xe9, 0xe7, 0xe6, 0xe4, 0xe2, 0xe0, 0xdd, 0xdb,
//     0xd9, 0xd7, 0xd4, 0xd2, 0xd0, 0xcd, 0xcb, 0xc8, 0xc5, 0xc3, 0xc0, 0xbd, 0xbb, 0xb8, 0xb5, 0xb2,
//     0xaf, 0xac, 0xa9, 0xa6, 0xa3, 0xa0, 0x9d, 0x9a, 0x97, 0x94, 0x91, 0x8e, 0x8b, 0x87, 0x84, 0x81,
//     0x7e, 0x7b, 0x78, 0x74, 0x71, 0x6e, 0x6b, 0x68, 0x65, 0x62, 0x5f, 0x5c, 0x59, 0x56, 0x53, 0x50,
//     0x4d, 0x4a, 0x47, 0x44, 0x42, 0x3f, 0x3c, 0x3a, 0x37, 0x34, 0x32, 0x2f, 0x2d, 0x2b, 0x28, 0x26,
//     0x24, 0x22, 0x1f, 0x1d, 0x1b, 0x19, 0x18, 0x16, 0x14, 0x12, 0x11, 0x0f, 0x0e, 0x0c, 0x0b, 0x0a,
//     0x09, 0x07, 0x06, 0x05, 0x04, 0x04, 0x03, 0x02, 0x02, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
//     0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x02, 0x03, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09,
//     0x0a, 0x0c, 0x0d, 0x0e, 0x10, 0x12, 0x13, 0x15, 0x17, 0x18, 0x1a, 0x1c, 0x1e, 0x20, 0x23, 0x25,
//     0x27, 0x29, 0x2c, 0x2e, 0x31, 0x33, 0x36, 0x38, 0x3b, 0x3e, 0x40, 0x43, 0x46, 0x49, 0x4b, 0x4e,
//     0x51, 0x54, 0x57, 0x5a, 0x5d, 0x60, 0x63, 0x66, 0x6a, 0x6d, 0x70, 0x73, 0x76, 0x79, 0x7c, 0x7f,
// };

static uint8_t sine_table[4096] = {
    0x80, 0x83, 0x86, 0x89, 0x8c, 0x8f, 0x92, 0x95, 0x99, 0x9c, 0x9f, 0xa2, 0xa5, 0xa8, 0xab, 0xae,
    0xb1, 0xb4, 0xb6, 0xb9, 0xbc, 0xbf, 0xc1, 0xc4, 0xc7, 0xc9, 0xcc, 0xce, 0xd1, 0xd3, 0xd6, 0xd8,
    0xda, 0xdc, 0xdf, 0xe1, 0xe3, 0xe5, 0xe7, 0xe8, 0xea, 0xec, 0xed, 0xef, 0xf1, 0xf2, 0xf3, 0xf5,
    0xf6, 0xf7, 0xf8, 0xf9, 0xfa, 0xfb, 0xfc, 0xfc, 0xfd, 0xfe, 0xfe, 0xff, 0xff, 0xff, 0xff, 0xff,
    0xff, 0xff, 0xff, 0xff, 0xff, 0xfe, 0xfe, 0xfd, 0xfd, 0xfc, 0xfb, 0xfb, 0xfa, 0xf9, 0xf8, 0xf6,
    0xf5, 0xf4, 0xf3, 0xf1, 0xf0, 0xee, 0xed, 0xeb, 0xe9, 0xe7, 0xe6, 0xe4, 0xe2, 0xe0, 0xdd, 0xdb,
    0xd9, 0xd7, 0xd4, 0xd2, 0xd0, 0xcd, 0xcb, 0xc8, 0xc5, 0xc3, 0xc0, 0xbd, 0xbb, 0xb8, 0xb5, 0xb2,
    0xaf, 0xac, 0xa9, 0xa6, 0xa3, 0xa0, 0x9d, 0x9a, 0x97, 0x94, 0x91, 0x8e, 0x8b, 0x87, 0x84, 0x81,
    0x7e, 0x7b, 0x78, 0x74, 0x71, 0x6e, 0x6b, 0x68, 0x65, 0x62, 0x5f, 0x5c, 0x59, 0x56, 0x53, 0x50,
    0x4d, 0x4a, 0x47, 0x44, 0x42, 0x3f, 0x3c, 0x3a, 0x37, 0x34, 0x32, 0x2f, 0x2d, 0x2b, 0x28, 0x26,
    0x24, 0x22, 0x1f, 0x1d, 0x1b, 0x19, 0x18, 0x16, 0x14, 0x12, 0x11, 0x0f, 0x0e, 0x0c, 0x0b, 0x0a,
    0x09, 0x07, 0x06, 0x05, 0x04, 0x04, 0x03, 0x02, 0x02, 0x01, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
    0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x01, 0x02, 0x03, 0x03, 0x04, 0x05, 0x06, 0x07, 0x08, 0x09,
    0x0a, 0x0c, 0x0d, 0x0e, 0x10, 0x12, 0x13, 0x15, 0x17, 0x18, 0x1a, 0x1c, 0x1e, 0x20, 0x23, 0x25,
    0x27, 0x29, 0x2c, 0x2e, 0x31, 0x33, 0x36, 0x38, 0x3b, 0x3e, 0x40, 0x43, 0x46, 0x49, 0x4b, 0x4e,
    0x51, 0x54, 0x57, 0x5a, 0x5d, 0x60, 0x63, 0x66, 0x6a, 0x6d, 0x70, 0x73, 0x76, 0x79, 0x7c, 0x7f,
};

void sine_generator_init(SineGenerator *sg, float fs) {
    for (uint32_t i = 0; i < 4096; i++) {
        float phase = (float)i * 2. * M_PI / 4096.;
        float value = sinf(phase) * 127. + 127.5;
        sine_table[i] = (uint8_t)value;
    }

    memset(sg, 0, sizeof(SineGenerator));
    sg->fs = fs;
}

static inline uint32_t _freq_to_ctw(float freq, float fs) {
    float ctw = freq * powf(2, 32) / fs;
    return (uint32_t)ctw;
}

void sine_generator_chirp_begin(SineGenerator *sg, float begin_freq, float end_freq, uint32_t n) {
    sg->chirp_running = true;

    sg->_chirp_end_ctw = _freq_to_ctw(end_freq, sg->fs);
    sg->_freq_ctw = _freq_to_ctw(begin_freq, sg->fs);
    sg->_freq_acc = 0;

    sg->_chirp_total_samples = n;
    sg->_chirp_samples_remain = sg->_chirp_total_samples;

    if (sg->_chirp_end_ctw == sg->_freq_ctw) {
        sg->_chirp_step_mul = 1U << SG_STEP_Q;
    } else {
        float ratio = end_freq / begin_freq;
        float step = powf(ratio, 1.0f / (float)sg->_chirp_total_samples);

        sg->_chirp_step_mul = (uint32_t)(step * (float)(1U << SG_STEP_Q));

        if (sg->_chirp_step_mul == 0) sg->_chirp_step_mul = 1;
    }
}

void sine_generator_single_freq_begin(SineGenerator *sg, float freq) {
    sg->chirp_running = false;

    sg->_freq_ctw = _freq_to_ctw(freq, sg->fs);
    sg->_freq_acc = 0;
}

void sine_generator_fill_buffer(SineGenerator *sg, uint16_t *buffer, uint32_t buffer_size) {
    for (uint32_t i = 0; i < buffer_size * 2; i++) {
        sg->_freq_acc += sg->_freq_ctw;

        if (i % 2 == 0)
            buffer[i >> 1] = sine_table[sg->_freq_acc >> SG_FREQ_Q];
        else
            buffer[i >> 1] |= sine_table[sg->_freq_acc >> SG_FREQ_Q] << 8;

        if (sg->chirp_running) {
            sg->_chirp_samples_remain--;

            if (sg->_chirp_samples_remain == 0) {
                sg->_freq_ctw = sg->_chirp_end_ctw;
                sg->chirp_running = false;
            } else {
                uint64_t prod = (uint64_t)sg->_freq_ctw * (uint64_t)sg->_chirp_step_mul;
                sg->_freq_ctw = (uint32_t)(prod >> SG_STEP_Q);
            }
        }
    }
}
